# Keil uVision project Miniproject.uvprojx, settings and files
target Target 1 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x008000) IROM(0x00000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Miniproject
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Source Group 1
    ../../SoftwarePackage_V1.05_CRLF (1)/: calculate_answer.c high_level_funcs.c low_level_funcs_tiva.c main.c mid_level_funcs.c calculate_answer.h high_level_funcs.h low_level_funcs_tiva.h mid_level_funcs.h
    ../Labf4_timer/: TExaS.h PLL.c
software components: CMSIS:CORE 5.0.1, Device:Startup 1.0.1
